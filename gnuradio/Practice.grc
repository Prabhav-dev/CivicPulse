options:
  parameters:
    generate_options: qt_gui
    id: Practice
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: interferer_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '2.0'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: interferer_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '16000'
    low_cutoff_freq: '8000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '0.001'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '12'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import requests
      import time

      class civicpulse_http_sink(gr.sync_block):
          """
          CivicPulse HTTP Telemetry Sink
          Calculates average power (dB) and posts JSON to CivicPulse.
          """
          def __init__(self, url="http://127.0.0.1:7070/ingest", mac="AA:BB:CC:DD:EE:FF", node_type="utilityline"):
              gr.sync_block.__init__(
                  self,
                  name='CivicPulse HTTP Sink',
                  in_sig=[np.float32],  # Accepts float stream from your filters/moving average
                  out_sig=None           # Sink block (no output stream)
              )
              if "[" in url and "](" in url:
                  url = url.split("](")[1].rstrip(")")
              self.url = url.strip().strip("'\"")
              self.mac = mac.strip().strip("'\"")
              self.node_type = node_type.strip().strip("'\"")
              self.last_send_time = 0.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              current_time = time.time()
              
              # Send telemetry once every 1.0 second to avoid flooding the backend
              if len(in0) > 0 and (current_time - self.last_send_time) >= 1.0:
                  # Calculate average power in relative dB
                  power_rms = float(np.mean(in0**2))
                  power_db = float(10 * np.log10(power_rms + 1e-12))

                  payload = {
                      "nodeType": self.node_type,
                      "mac": self.mac,
                      "rfPowerDb": round(power_db, 2),
                      "ts": int(current_time * 1000)
                  }
                  
                  headers = {"Content-Type": "application/json"}
                  
                  try:
                      # Non-blocking HTTP POST request to CivicPulse
                      resp = requests.post(self.url, json=payload, headers=headers, timeout=0.8)
                      print(f"[CivicPulse Sink] Ingested RF Power: {round(power_db, 2)} dB -> HTTP {resp.status_code}")
                  except Exception as e:
                      print(f"[CivicPulse Sink Warning] Could not post to {self.url}: {e}")
                      
                  self.last_send_time = current_time

              return len(in0)
    mac: '''AA:BB:CC:DD:EE:FF'''
    node_type: '''utilityline'''
    url: '''http://127.0.0.1:7070/ingest'''
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1420000000'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [digital_glfsr_source_x_0, '0', band_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
